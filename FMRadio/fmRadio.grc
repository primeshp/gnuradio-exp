options:
  parameters:
    generate_options: qt_gui
    id: fmRadio
    output_language: python
    title: Stereo FM Receiver
  states: {}

blocks:
- name: audioSrc
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,3,1,2
    label: Audio
    label0: Main
    label1: SCA 67 kHz
    label2: SCA 92 kHz
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
  states: {}
- name: audio_Hz
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: deviation_Hz
  id: variable
  parameters:
    comment: |-
      FM broadcast
      deviation.
    value: 75e3
  states: {}
- name: downRate_Hz
  id: variable
  parameters:
    value: 10* audio_Hz
  states: {}
- name: freq_MHz
  id: variable
  parameters:
    value: '104.5'
  states: {}
- name: fsPilot_Hz
  id: variable
  parameters:
    comment: |-
      Sample rate when working
      with 38 kHz stero pilot tone.
    value: 2 * audio_Hz
  states: {}
- name: lpTaps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 100e3
    gain: '1.0'
    samp_rate: downRate_Hz
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: mute
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,5,1,1
    label: Mute
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: rdsTaps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 2.6e3
    gain: '2500'
    samp_rate: 250e3
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: rfGain_dB
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,3
    label: RF Gain (dB)
    rangeType: int
    start: '10'
    step: '1'
    stop: '90'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      This rate provides
      a nice spectrum for
      Fosphor display.

      For RTL-SDR, use 2.4 MSa/s.
    value: 10 * downRate_Hz
  states: {}
- name: taps_sca
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 10e3
    gain: '1.0'
    samp_rate: downRate_Hz / 2
    width: 1e2
    win: window.WIN_HAMMING
  states: {}
- name: taps_sca_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 10e3
    gain: '1.0'
    samp_rate: downRate_Hz / 2
    width: 1e2
    win: window.WIN_HAMMING
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,3
    label: Volume
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: audio_Hz
    tau: '75e-6'
  states: {}
- name: analog_fm_deemph_0_1
  id: analog_fm_deemph
  parameters:
    comment: Undo pre-emphasis.
    samp_rate: audio_Hz
    tau: '75e-6'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '10'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: 480e3
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_fm_demod_cf_0_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '10'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: 480e3
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    comment: |-
      ~19 kHz pilot

      Lock onto received
      f=~19 kHz pilot +/- 0.01 rad.
      (2 pi f) / fs = 1.24 rad/Sa
    max_freq: (2 * 3.1416 * 19e3) / (2 * audio_Hz) + 0.1
    min_freq: (2 * 3.1416 * 19e3) / (2 * audio_Hz) - 0.1
    w: (2 * 3.1416)/100
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    comment: Soundcard.
    num_inputs: '2'
    samp_rate: int(audio_Hz)
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    comment: |-
      Output:
        96 kSa/s
        fc=19 kHz
        bw=2 kHz
    decim: int(downRate_Hz / fsPilot_Hz)
    gain: '1'
    high_cutoff_freq: 20e3
    low_cutoff_freq: 18e3
    samp_rate: downRate_Hz
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    comment: Clean PLL output.
    decim: '1'
    gain: '1'
    high_cutoff_freq: 39e3
    low_cutoff_freq: 37e3
    samp_rate: fsPilot_Hz
    type: fir_filter_ccf
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_1
  id: band_pass_filter
  parameters:
    comment: |-
      Output:
        96 kSa/s
        fc=38 kHz
        bw: 30 kHz
    decim: int(downRate_Hz / fsPilot_Hz)
    gain: '10'
    high_cutoff_freq: 53e3
    low_cutoff_freq: 23e3
    samp_rate: downRate_Hz
    type: fir_filter_fcc
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: Recover 2L.
    type: float
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters:
    comment: |-
      Quadrature demod:
      arg(x_n / x_n-1)
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    comment: x_n-1
    delay: '1'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    comment: x_n / x_n-1
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '2'
    type: byte
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq_MHz
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Volume.
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Volume.
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Volume.
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: Gain
    const: 8 * downRate_Hz / (2 * 3.1416 * deviation_Hz)
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: ~38 kHz pilot
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    comment: |-
      Mix L-R to
      baseband.
    type: complex
  states: {}
- name: blocks_mute_xx_0
  id: blocks_mute_xx
  parameters:
    mute: mute
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: audioSrc
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    comment: |-
      Select Main or SCA audio.
      Controlled by GUI.
    enabled: 'True'
    input_index: audioSrc
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    comment: Recover 2R.
    type: float
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_psk_demod_0_0
  id: digital_psk_demod
  parameters:
    comment: DEPRECATED - UPDATE ME!
    constellation_points: '2'
    differential: 'False'
    excess_bw: '0.35'
    freq_bw: 6.28/100.0
    mod_code: '"gray"'
    phase_bw: 6.28/100.0
    samples_per_symbol: '4'
    timing_bw: 6.28/100.0
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      '''Convert an arbitrary frequency in the FM broadcast band to the frequency
      of the nearest radio station frequency.

      Mike Markowski, mike.ab3ap@gmail.com
      Feb 2021
      '''

      import numpy as np
      from gnuradio import gr
      import pmt

      class snapBlock(gr.basic_block):

      	def __init__(self):
      		gr.basic_block.__init__(
      			self,
      			name="Snap to Station",
      			in_sig=None,
      			out_sig=None)

      		# User input that is only somewhere near a station frequency.
      		self.message_port_register_in(pmt.intern('raw_Hz_in'))
      		self.set_msg_handler(pmt.intern('raw_Hz_in'), self.stationSnap)

      		# Output in Hz and MHz that is exactly a station frequency.
      		self.message_port_register_out(pmt.intern('snapped_Hz_out'))
      		self.message_port_register_out(pmt.intern('snapped_MHz_out'))

      	def stationSnap(self, msg):

      		'''Accept a pmt pair with user selected frequency information and
      		adjust it to the nearest broadcast FM frequency.

      		Inputs:
      		  msg (dictionary) : assumed to contain only: (freq . <float>)

      		Outputs:
      		  freq_Hz_out (pmt.dict) : (freq . snappedFreq) where snappedFreq
      		    is input frequency in Hz moved to nearest broadcast frequency.
      		  freq_MHz_out (pmt.dict) : (freq . snappedFreq) where snappedFreq
      		    is input frequency in MHz moved to nearest broadcast frequency.
      		'''

      		# Disassemble pmt pair.
      		cmd = pmt.car(msg)
      		freq = pmt.cdr(msg)
      		freqRaw_MHz = pmt.to_python(freq) / 1e6 # Easier to work in MHz.

      		# Snap user-clicked freq to nearest FM station.
      		spacing = 0.2 # N. American broadcast FM spacing in MHz.
      		nearest = 0.1 # Round to nearest odd tenth of MHz.
      		freq_MHz = nearest + round((freqRaw_MHz - nearest)/spacing) * spacing
      		freq_Hz = freq_MHz * 1e6

      		# Generate output message, (freq . freq_Hz).
      		pair = pmt.cons(cmd, pmt.to_pmt(freq_Hz))
      		self.message_port_pub(pmt.intern('snapped_Hz_out'), pair)

      		# Generate output message, (freq . freq_MHz).
      		pair = pmt.cons(cmd, pmt.to_pmt(freq_MHz))
      		self.message_port_pub(pmt.intern('snapped_MHz_out'), pair)
    comment: |-
      Snap user choice
      to nearest station.
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      '''Convert a pmt pair (freq . f_Hz) to (freq . f_MHz).

      Mike Markowski, mike.ab3ap@gmail.com
      Feb 2021
      '''

      import numpy as np
      from gnuradio import gr
      import pmt

      class cvtBlock(gr.basic_block):

      	def __init__(self):
      		"""arguments to this function show up as parameters in GRC"""
      		gr.basic_block.__init__(
      			self,
      			name='MHz to Hz',
      			in_sig=None,
      			out_sig=None
      		)

      		self.message_port_register_in(pmt.intern('freq_MHz_in'))
      		self.set_msg_handler(pmt.intern('freq_MHz_in'), self.MHzToHz)

      		self.message_port_register_out(pmt.intern('freq_Hz_out'))

      	def MHzToHz(self, msg):
      		'''msg expected to be pmt pair (freq . val).'''

      		cmd = pmt.car(msg)
      		freq_Hz = 1e6 * pmt.to_python(pmt.cdr(msg))

      		hzDict = pmt.make_dict()
      		hzDict = pmt.dict_add(hzDict, cmd, pmt.to_pmt(freq_Hz))
      		self.message_port_pub(pmt.intern('freq_Hz_out'), hzDict)
    comment: |-
      MHz is easier to work with,
      but SDR needs Hz.
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: lpTaps
    type: fff
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: freq_MHz * 1e6
    freq_span: samp_rate
    gui_hint: 'spectra@0 : 0,0,1,1'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 57e3
    decim: '1'
    samp_rate: 250e3
    taps: rdsTaps
    type: fcf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 67.65e3
    decim: '2'
    samp_rate: downRate_Hz
    taps: taps_sca
    type: fcf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 92e3
    decim: '2'
    samp_rate: downRate_Hz
    taps: taps_sca
    type: fcf
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: |-
      Channel to baseband:
        480 kSa/s
        bw=100 kHz
    cutoff_freq: 100e3
    decim: int(samp_rate / downRate_Hz)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    comment: Mono filtered to 15 kHz cutoff.
    cutoff_freq: 15e3
    decim: int(downRate_Hz / audio_Hz)
    gain: '1'
    samp_rate: downRate_Hz
    type: fir_filter_fff
    width: 1.5e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    comment: Audio filtered to 15 kHz cutoff.
    cutoff_freq: 15e3
    decim: '2'
    gain: '1'
    samp_rate: fsPilot_Hz
    type: fir_filter_ccf
    width: 1.5e3
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    alias: 'Inspired by URL: https://www.nutsvolts.com/magazine/article/fm-reception-with-the-gnu-radio-companion'
    comment: |-
      Mike Markowski
      Feb 4, 2021
      mike.ab3ap@gmail.com

      Inspired by and modeled after URL: 
      https://www.nutsvolts.com/magazine/article/fm-reception-with-the-gnu-radio-companion
    note: FM radio project!
  states: {}
- name: note_0_0
  id: note
  parameters:
    alias: 'Inspired by URL: https://www.nutsvolts.com/magazine/article/fm-reception-with-the-gnu-radio-companion'
    comment: |-
      GUI blocks here are laid
      out as in displayed GUI.
    note: GUI info
  states: {}
- name: note_0_1
  id: note
  parameters:
    comment: |-
      Tune to desired station and
      output 100 kHz channel.
    note: Tuner
  states: {}
- name: note_0_1_0
  id: note
  parameters:
    comment: |-
      *** samp_rate must be a multiple of
      downRate_Hz, and downRate_Hz must be
      a multiple of audio_Hz.
    note: Rates
  states: {}
- name: note_1
  id: note
  parameters:
    comment: |-
      This simply supports clicking
      on QT Gui Sink  to change stations.
    note: GUI Niceties
  states: {}
- name: note_2
  id: note
  parameters:
    comment: |-
      fc=67.65 kHz
      bw=18 kHz
      FM modulated
    note: SCA1
  states: {}
- name: note_2_0
  id: note
  parameters:
    comment: |-
      fc=92 kHz
      bw=16 kHz
      FM modulated
    note: SCA2
  states: {}
- name: note_2_0_0
  id: note
  parameters:
    comment: |-
      GUI is used to select
        Stereo main,
        Mono SCA@67 kHz, or
        Mono SCA@92 kHz.
    note: Audio source
  states: {}
- name: note_3
  id: note
  parameters:
    comment: |-
      fc=57 kHz, 3rd harmonic of pilot.
      1187.5 b/s (48 subcarrier cycles/bit).
    note: RDS
  states: {}
- name: note_4
  id: note
  parameters:
    note: L+R
  states: {}
- name: note_4_0
  id: note
  parameters:
    note: 19 kHz pilot
  states: {}
- name: note_4_0_0
  id: note
  parameters:
    note: 38 kHz pilot
  states: {}
- name: note_4_0_1
  id: note
  parameters:
    note: L-R
  states: {}
- name: note_5
  id: note
  parameters:
    note: Stereo signals
  states: {}
- name: note_6
  id: note
  parameters:
    comment: |-
      If you don't have gr-fosphor
      installed, use QT GUI Sink.
    note: GUI choice
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    comment: |-
      Output:
        19 kSa/s
    nfilts: '32'
    rrate: 19000/250e3
    type: ccf
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 1,3, 1,1
    key: freq
    label: Freq (MHz)
    type: float
    value: '104.5'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: audio_Hz
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 'spectra@3 : 0,0,1,1'
    legend: 'False'
    name: L+R
    type: float
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: 2e3
    fc: 19e3
    fftsize: '2048'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 'spectra@4 : 0,0,1,1'
    legend: 'False'
    name: 19 kHz Pilot
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: 2e3
    fc: 38e3
    fftsize: '2048'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 'spectra@5 : 0,0,1,1'
    legend: 'False'
    name: 38 kHz Pilot
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: audio_Hz
    fc: 38e3
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 'spectra@6 : 0,0,1,1'
    legend: 'False'
    name: L-R
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: audio_Hz
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 'spectra@7 : 0,0,1,1'
    label1: Left
    label2: Right
    name: Left & Right
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_1_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: audio_Hz
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 'spectra@8 : 0,0,1,1'
    legend: 'False'
    name: SCA
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_1_1_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: audio_Hz
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 'spectra@9 : 0,0,1,1'
    legend: 'False'
    name: SCA
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: downRate_Hz
    fc: '0'
    fftsize: '8192'
    gui_hint: 'spectra@2 : 0,0,1,1'
    name: Tuned Station
    type: float
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq_MHz * 1e6
    fftsize: '1024'
    gui_hint: 'spectra@1 : 0,0,1,1'
    name: Full Spectrum
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: 'Output: 250 kSa/s'
    decim: '48'
    interp: '25'
    taps: ''
    type: fff
  states: {}
- name: rds_decoder_0
  id: rds_decoder
  parameters: {}
  states: {}
- name: rds_panel_0
  id: rds_panel
  parameters:
    gui_hint: 5,0,1,10
  states: {}
- name: rds_parser_0
  id: rds_parser
  parameters:
    pty_locale: '1'
  states: {}
- name: root_raised_cosine_filter_0_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '1'
    decim: '2'
    gain: '1'
    ntaps: '100'
    samp_rate: '19000'
    sym_rate: '2375'
    type: fir_filter_ccf
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    comment: 'Output: 2.4 MSa/s'
    dc_offset_mode0: '2'
    freq0: freq_MHz * 1e6
    gain0: rfGain_dB
    gain_mode0: 'True'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: spectra
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,9
    label0: RTSA
    label1: Full Spectrum
    label10: RDS Symbols
    label2: Station Channel
    label3: L+R
    label4: 19 kHz Pilot
    label5: 38 kHz Pilot
    label6: L-R
    label7: Left & Right
    label8: SCA 67 kHz
    label9: SCA 92 kHz
    num_tabs: '11'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: samp_rate
    center_freq0: freq_MHz * 1e6
    dev_args: '""'
    gain0: rfGain_dB
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    comment: |-
      Demodulated station:
        480 kSa/s
        bw=100 kHz
    stream_id: baseband
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    comment: |-
      Audio output:
        48 kSa/s
         bw=15 kHz
    stream_id: L+R
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    comment: |-
      Output:
        96 kSa/s
        fc=38 kHz
        bw=2 kHz
    stream_id: 38 kHz pilot
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    comment: |-
      Audio output:
        48 kSa/s
        bw=15 kHz
    stream_id: L-R
  states: {}
- name: virtual_sink_0_0_1_0
  id: virtual_sink
  parameters:
    comment: |-
      Output:
        48 kSa/s
        audio bw: 9 kHz
    stream_id: scaAudio67
  states: {}
- name: virtual_sink_0_0_1_0_0
  id: virtual_sink
  parameters:
    comment: Left Speaker.
    stream_id: mainL
  states: {}
- name: virtual_sink_0_0_1_0_0_0
  id: virtual_sink
  parameters:
    comment: |-
      Right Speaker:
        48 kSa/s
        audio bw: 15 kHz
    stream_id: mainR
  states: {}
- name: virtual_sink_0_0_1_0_1
  id: virtual_sink
  parameters:
    comment: |-
      Output:
        48 kSa/s
        audio bw: 9 kHz
    stream_id: scaAudio92
  states: {}
- name: virtual_sink_0_0_2
  id: virtual_sink
  parameters:
    comment: |-
      Output:
        96 kSa/s
        fc=19 kHz
        bw=2 kHz

        Unfiltered!
    stream_id: 19 kHz pilot
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rdsSym
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    comment: |-
      Station chosen by user
      via QT Gui Sink.
    stream_id: fmStation_Hz
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    comment: |-
      Station chosen
      by clicking gui.
    stream_id: fmStation_MHz
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    comment: |-
      480 kSa/s
      bw=100 kHz
    stream_id: baseband
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    comment: |-
      480 kSa/s
      bw=100 kHz
    stream_id: baseband
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: 19 kHz pilot
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    comment: |-
      480 kSa/s
      bw=100 kHz
    stream_id: baseband
  states: {}
- name: virtual_source_0_0_1_0
  id: virtual_source
  parameters:
    comment: |-
      480 kSa/s
      bw=100 kHz
    stream_id: baseband
  states: {}
- name: virtual_source_0_0_1_0_0
  id: virtual_source
  parameters:
    comment: |-
      480 kSa/s
      bw=100 kHz
    stream_id: baseband
  states: {}
- name: virtual_source_0_0_1_0_0_0
  id: virtual_source
  parameters:
    comment: |-
      480 kSa/s
      bw=100 kHz
    stream_id: baseband
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: 38 kHz pilot
  states: {}
- name: virtual_source_0_1_1
  id: virtual_source
  parameters:
    stream_id: L+R
  states: {}
- name: virtual_source_0_1_1_0
  id: virtual_source
  parameters:
    stream_id: L-R
  states: {}
- name: virtual_source_0_1_2_0_0
  id: virtual_source
  parameters:
    comment: Main Left.
    stream_id: mainL
  states: {}
- name: virtual_source_0_1_2_0_0_0
  id: virtual_source
  parameters:
    comment: Main Right.
    stream_id: mainR
  states: {}
- name: virtual_source_0_1_2_0_0_1
  id: virtual_source
  parameters:
    comment: SCA at 67 kHz.
    stream_id: scaAudio67
  states: {}
- name: virtual_source_0_1_2_0_0_1_0
  id: virtual_source
  parameters:
    comment: SCA at 92 kHz.
    stream_id: scaAudio92
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    comment: Extract RDS information.
    stream_id: rdsSym
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    comment: |-
      Station chosen by user
      via QT Gui Sink.
    stream_id: fmStation_Hz
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    comment: |-
      Station chosen
      by clicking gui.
    stream_id: fmStation_MHz
  states: {}

connections:
- [analog_fm_deemph_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_fm_deemph_0_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [analog_fm_demod_cf_0_0, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [analog_pll_refout_cc_0, '0', virtual_sink_0_0_2, '0']
- [band_pass_filter_0, '0', blocks_float_to_complex_0, '0']
- [band_pass_filter_0, '0', blocks_float_to_complex_0, '1']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [band_pass_filter_0_0, '0', blocks_complex_to_real_0_0, '0']
- [band_pass_filter_0_0, '0', virtual_sink_0_0_0, '0']
- [band_pass_filter_0_1, '0', blocks_multiply_xx_0_0, '1']
- [blocks_add_xx_0, '0', analog_fm_deemph_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_complex_to_real_0, '0', qtgui_freq_sink_x_0_0_1, '0']
- [blocks_complex_to_real_0, '0', virtual_sink_0_0_1, '0']
- [blocks_complex_to_real_0_0, '0', qtgui_freq_sink_x_0_0_0_0, '0']
- [blocks_delay_0_0, '0', blocks_divide_xx_0, '1']
- [blocks_divide_xx_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_float_to_complex_0, '0', analog_pll_refout_cc_0, '0']
- [blocks_keep_one_in_n_0, '0', digital_diff_decoder_bb_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0_0_1_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0_0_1_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_freq_sink_x_0_0_1_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', virtual_sink_0_0_1_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', qtgui_freq_sink_x_0_0_1_1, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', virtual_sink_0_0_1_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0, '0', qtgui_freq_sink_x_0_0_1_1_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0, '0', virtual_sink_0_0_1_0_1, '0']
- [blocks_multiply_const_vxx_1, '0', fir_filter_xxx_0, '0']
- [blocks_multiply_xx_0, '0', band_pass_filter_0_0, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0_0_0, '0']
- [blocks_mute_xx_0, '0', fosphor_qt_sink_c_0, '0']
- [blocks_mute_xx_0, '0', low_pass_filter_0, '0']
- [blocks_mute_xx_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_selector_0, '0', audio_sink_0_0, '0']
- [blocks_selector_0_0, '0', audio_sink_0_0, '1']
- [blocks_sub_xx_0, '0', analog_fm_deemph_0_1, '0']
- [digital_diff_decoder_bb_0, '0', rds_decoder_0, '0']
- [digital_psk_demod_0_0, '0', virtual_sink_1, '0']
- [epy_block_0, snapped_Hz_out, qtgui_sink_x_0_0, freq]
- [epy_block_0, snapped_MHz_out, blocks_msgpair_to_var_0, inpair]
- [epy_block_0, snapped_MHz_out, virtual_sink_2_0, '0']
- [epy_block_1, freq_Hz_out, virtual_sink_2, '0']
- [fir_filter_xxx_0, '0', qtgui_sink_x_0, '0']
- [fir_filter_xxx_0, '0', virtual_sink_0, '0']
- [fosphor_qt_sink_c_0, freq, epy_block_0, raw_Hz_in]
- [freq_xlating_fir_filter_xxx_0, '0', pfb_arb_resampler_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_fm_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', analog_fm_demod_cf_0_0, '0']
- [low_pass_filter_0, '0', blocks_delay_0_0, '0']
- [low_pass_filter_0, '0', blocks_divide_xx_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0_0, '0', virtual_sink_0_0, '0']
- [low_pass_filter_0_0_0, '0', blocks_complex_to_real_0, '0']
- [pfb_arb_resampler_xxx_0, '0', root_raised_cosine_filter_0_0_0, '0']
- [qtgui_edit_box_msg_0, msg, epy_block_1, freq_MHz_in]
- [qtgui_sink_x_0_0, freq, epy_block_0, raw_Hz_in]
- [rational_resampler_xxx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rds_decoder_0, out, rds_parser_0, in]
- [rds_parser_0, out, rds_panel_0, in]
- [root_raised_cosine_filter_0_0_0, '0', digital_psk_demod_0_0, '0']
- [rtlsdr_source_0, '0', blocks_mute_xx_0, '0']
- [uhd_usrp_source_0, '0', blocks_mute_xx_0, '0']
- [virtual_source_0, '0', low_pass_filter_0_0, '0']
- [virtual_source_0_0, '0', band_pass_filter_0, '0']
- [virtual_source_0_0_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_0_0_0, '0', blocks_multiply_xx_0, '1']
- [virtual_source_0_0_1, '0', band_pass_filter_0_1, '0']
- [virtual_source_0_0_1_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [virtual_source_0_0_1_0_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [virtual_source_0_0_1_0_0_0, '0', rational_resampler_xxx_0, '0']
- [virtual_source_0_1_0, '0', blocks_multiply_xx_0_0, '0']
- [virtual_source_0_1_1, '0', blocks_add_xx_0, '0']
- [virtual_source_0_1_1, '0', blocks_sub_xx_0, '0']
- [virtual_source_0_1_1_0, '0', blocks_add_xx_0, '1']
- [virtual_source_0_1_1_0, '0', blocks_sub_xx_0, '1']
- [virtual_source_0_1_2_0_0, '0', blocks_selector_0, '0']
- [virtual_source_0_1_2_0_0_0, '0', blocks_selector_0_0, '0']
- [virtual_source_0_1_2_0_0_1, '0', blocks_selector_0, '1']
- [virtual_source_0_1_2_0_0_1, '0', blocks_selector_0_0, '1']
- [virtual_source_0_1_2_0_0_1_0, '0', blocks_selector_0, '2']
- [virtual_source_0_1_2_0_0_1_0, '0', blocks_selector_0_0, '2']
- [virtual_source_1, '0', blocks_keep_one_in_n_0, '0']
- [virtual_source_2, '0', rtlsdr_source_0, command]
- [virtual_source_2, '0', uhd_usrp_source_0, command]
- [virtual_source_2_0, '0', qtgui_edit_box_msg_0, val]

metadata:
  file_format: 1

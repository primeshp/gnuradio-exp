options:
  parameters:
    author: primeshpinto
    generate_options: qt_gui
    id: receive_uhd
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 88e6
    step: '100000'
    stop: 108e6
    value: 100.5e6
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '960000'
  states: {}
- name: fosphor_glfw_sink_c_0
  id: fosphor_glfw_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: xmlrpc_client_0
  id: xmlrpc_client
  parameters:
    addr: 192.168.21.49
    callback: set_center_freq
    port: '8080'
    variable: freq
  states: {}
- name: xmlrpc_client_0_0
  id: xmlrpc_client
  parameters:
    addr: 192.168.21.49
    callback: set_rf_gain
    port: '8080'
    variable: rf_gain
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://192.168.21.49:9997
    timeout: '100'
    type: complex
  states: {}

connections:
- [zeromq_pull_source_0, '0', fosphor_glfw_sink_c_0, '0']
- [zeromq_pull_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1

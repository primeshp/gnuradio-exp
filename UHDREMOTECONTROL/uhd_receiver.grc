options:
  parameters:
    generate_options: no_gui
    id: udh_receiver
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: parameter
  parameters:
    label: Center Frequency
    value: 100.5e6
  states: {}
- name: rf_gain
  id: parameter
  parameters:
    label: RF Gain
    value: '20'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    value: '960000'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: center_freq
    dc_offs_enb0: '""'
    dev_addr: '"serial=30AEBEE"'
    dev_args: '""'
    gain0: rf_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 192.168.21.49
    port: '8080'
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://*:9997
    timeout: '100'
    type: complex
  states: {}

connections:
- [uhd_usrp_source_0, '0', zeromq_push_sink_0, '0']

metadata:
  file_format: 1

options:
  parameters:
    author: primeshp
    generate_options: qt_gui
    id: PacketsExperiment
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_crc(len_key, num_key)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: ' pmt.cons(pmt.PMT_NIL,pmt.init_u8vector(9,(71,78,85,32,82,97,100,105,111)))'
    period: '1000'
  states: {}
- name: digital_crc32_async_bb_0
  id: digital_crc32_async_bb
  parameters:
    check: 'False'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters: {}
  states: {}

connections:
- [blocks_message_strobe_0, strobe, digital_crc32_async_bb_0, in]
- [digital_crc32_async_bb_0, out, digital_protocol_formatter_async_0, in]

metadata:
  file_format: 1

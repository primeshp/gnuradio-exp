options:
  parameters:
    generate_options: qt_gui
    id: symbol_sync_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: int(samp_rate/(sps*symbol_rate))
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: rf_decim
  id: variable
  parameters:
    value: int(samp_rate/(sps*symbol_rate))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sdr_rate
  id: variable
  parameters:
    value: '960000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '512'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation_hz/8.0)
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/primeshp/test.bin
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Inverted the Signal
    const: '-0.02'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: '"packet_len"'
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/primeshp/gnuradio-exp/Pager/gqrx_20230413_201020_154464900.wav
    repeat: 'False'
  states: {state: disabled}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '01111100110100100001010111011000'
    comment: This ouput is ready for POCSAG decoder to use
    tagname: '"start"'
    threshold: '0'
    type: byte
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_EARLY_LATE
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
       
      class blk(gr.sync_block):
          def __init__(self,tracking_tag="start", length_tag="packet_len",length=512):
              gr.sync_block.__init__(self,name='Tagged Data Dump', in_sig=[np.uint8], out_sig=[np.uint8])
              self.tracking_tag =tracking_tag
              self.length_tag= length_tag
              self.length=length

          def work(self, input_items, output_items):
              tags = self.get_tags_in_window(0, 0, len(input_items[0]))

              for tag in tags:
                  key = pmt.to_python(tag.key) # convert from PMT to python string
                  #value = pmt.to_python(tag.value) # Note that the type(value) can be several things, it depends what PMT type it was
                  #offset= int(pmt.to_python(tag.offset))
                  if (key==self.tracking_tag):
                      #print('key:', key)
                      #print('value:', value, type(value))
                      #print("offset", tag.offset)
                      #print('')
                      #tx_key = pmt.intern("example_key")
                      #tx_value = pmt.intern("example_value")
                      self.add_item_tag(0, # Write to output port 0
                              tag.offset,
                              pmt.intern(self.length_tag),# Key of the tag
                              pmt.from_double(self.length), #Value of the tag
                      )
                      

              output_items[0][:] = input_items[0]
              return len(input_items[0])
    length: '64'
    length_tag: '"packet_len"'
    tracking_tag: '"start"'
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: int(sdr_rate/samp_rate)
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, sdr_rate, -1*sdr_rate/(2*rf_decim),sdr_rate/(2*rf_decim), 1000)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: '"pmt"'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '700'
    decim: decim
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      This Flowgraph take the waveform saved 
      using GQRX and decode it
      This is configured to receive Pager signals from
      Eversource.

      Eversource Energy Service Company
      SOUTH MOUNTAIN WILLIS ST + Multiple Other locations
      BRISTOL, CT HARTFORD County  
      Fequency: 000154.46375000 FSK (Bristal Has a Transmitter)

      rtl_fm -M fm -f 154463600 -s 22050 -g 100 -l 310  | multimon-ng -t raw -a POCSAG512 -a POCSAG1200 -a POCSAG2400 -a scope /dev/stdin
    note: Use of the Flowgraph
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"rtl_tcp=192.168.21.66:1234"'
    bb_gain0: '20'
    freq0: '154463600'
    gain0: '40'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: symbol_rate
    tr_delay: '-10'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"burst"'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: symbol_rate*sps
    type: float
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate/decim
    tr_tag: '"start"'
    type: float
  states: {}
- name: satellites_sync_to_pdu_0
  id: satellites_sync_to_pdu
  parameters:
    packlen: '64'
    sync: '"01111100110100100001010111011000"'
    threshold: '4'
  states: {state: disabled}
- name: satellites_sync_to_pdu_packed_0
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '64'
    sync: '"01111100110100100001010111011000"'
    threshold: '1'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rf_rx
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: sync_bits
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rf_rx
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: sync_bits
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', virtual_sink_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_repack_bits_bb_1, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print]
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [digital_binary_slicer_fb_0, '0', virtual_sink_1, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_char_to_float_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_file_sink_1, '0']
- [digital_correlate_access_code_tag_xx_0, '0', epy_block_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '1', blocks_null_sink_0, '0']
- [digital_symbol_sync_xx_0, '2', qtgui_number_sink_0, '0']
- [digital_symbol_sync_xx_0, '3', qtgui_number_sink_0, '1']
- [epy_block_0, '0', blocks_repack_bits_bb_1, '0']
- [epy_block_0, '0', blocks_tag_debug_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [satellites_sync_to_pdu_0, out, blocks_message_debug_0, print_pdu]
- [satellites_sync_to_pdu_packed_0, out, blocks_message_debug_0, print_pdu]
- [virtual_source_0, '0', low_pass_filter_0, '0']
- [virtual_source_0_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [virtual_source_0_0, '0', satellites_sync_to_pdu_0, '0']
- [virtual_source_0_0, '0', satellites_sync_to_pdu_packed_0, '0']

metadata:
  file_format: 1

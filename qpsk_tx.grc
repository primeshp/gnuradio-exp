options:
  parameters:
    author: Barry Duggan
    category: Custom
    description: Baseband packet
    generate_options: qt_gui
    id: pkt_7_base
    output_language: python
    title: pkt_7_base
  states: {}

blocks:
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_crc
    value: digital.header_format_crc(len_key, num_key)
  states: {}
- name: len_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: num_key
  id: variable
  parameters:
    value: '"packet_num"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e3
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/primeshp/gnuradio/test.iq
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_message_debug_0_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_1_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL,pmt.init_u8vector(37,(75, 90, 49, 66, 76, 90, 32, 84, 104, 105, 115, 32, 105, 115, 32, 84, 101, 115, 116, 32, 81, 80, 83, 75, 32, 84, 114, 97, 115, 110, 109, 105, 115, 115, 105, 111, 110)))
    period: '10000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_1
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: digital_crc32_async_bb_1
  id: digital_crc32_async_bb
  parameters:
    check: 'False'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: pkt_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: pkt_out
  states: {}

connections:
- [blocks_message_strobe_0, strobe, digital_crc32_async_bb_1, in]
- [blocks_packed_to_unpacked_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_throttle_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '0']
- [blocks_pdu_to_tagged_stream_1, '0', blocks_tagged_stream_mux_0, '1']
- [blocks_repack_bits_bb_1_0, '0', blocks_throttle_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_repack_bits_bb_1_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_throttle_0, '0', virtual_sink_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_throttle_0, '0']
- [digital_crc32_async_bb_1, out, blocks_message_debug_0_1, print_pdu]
- [digital_crc32_async_bb_1, out, digital_protocol_formatter_async_0, in]
- [digital_protocol_formatter_async_0, header, blocks_message_debug_0_1_0, print_pdu]
- [digital_protocol_formatter_async_0, header, blocks_pdu_to_tagged_stream_0, pdus]
- [digital_protocol_formatter_async_0, payload, blocks_message_debug_0_1_0, print_pdu]
- [digital_protocol_formatter_async_0, payload, blocks_pdu_to_tagged_stream_1, pdus]
- [virtual_source_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1

options:
  parameters:
    author: primeshp
    generate_options: qt_gui
    id: test_tags
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
       
      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
       
          def work(self, input_items, output_items):
              for indx, sample in enumerate(input_items[0]): # Enumerate through the input samples in port in0
                  if np.random.rand() > 0.95: # 5% chance this sample is chosen
                      key = pmt.intern("example_key")
                      value = pmt.intern("example_value")
                      self.add_item_tag(0, # Write to output port 0
                          self.nitems_written(0) + indx, # Index of the tag in absolute terms
                          key, # Key of the tag
                          value # Value of the tag
                      )
                       # note: (self.nitems_written(0) + indx) is our current sample, in absolute time
              output_items[0][:] = input_items[0] # copy input to output
              return len(output_items[0])
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', epy_block_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1

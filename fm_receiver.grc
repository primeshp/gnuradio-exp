options:
  parameters:
    generate_options: qt_gui
    id: Test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: decimation_factor
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '960000'
  states: {}
- name: tuned_freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 88000e3
    step: '1'
    stop: 108000e3
    value: 100500e3
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '3000'
    gain: '1.0'
    samp_rate: samp_rate/decimation_factor
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.1'
    stop: '1.0'
    value: '0.5'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: '48000'
    tau: '75e-6'
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: '1.3'
    min_freq: '0.9'
    w: '0.500'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate/decimation_factor
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '19000'
    low_cutoff_freq: '18000'
    samp_rate: samp_rate/decimation_factor
    type: fir_filter_fcc
    width: '500'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '39000'
    low_cutoff_freq: '37000'
    samp_rate: samp_rate/decimation_factor
    type: fir_filter_ccc
    width: '500'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '53000'
    low_cutoff_freq: '23000'
    samp_rate: samp_rate/decimation_factor
    type: fir_filter_fcc
    width: '500'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 3*19000
    decim: '16'
    samp_rate: samp_rate/decimation_factor
    taps: variable_low_pass_filter_taps_0
    type: fcc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    decim: decimation_factor
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '4'
    gain: '1'
    samp_rate: samp_rate/decimation_factor
    type: fir_filter_ccf
    width: '2000'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '4'
    gain: '1'
    samp_rate: samp_rate/decimation_factor
    type: fir_filter_fff
    width: '2000'
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: L+R
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: 19KHz pilot
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: 38KHz pilot
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: L-R
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"rtl_tcp=192.168.21.49:1234"'
    bb_gain0: '20'
    freq0: tuned_freq
    gain0: '40'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: samp_rate/decimation_factor
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    name: '"Baseband"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate/decimation_factor
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    name: '"Pilot 19KHz"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate/decimation_factor/16
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    name: '"RDS Baseband"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: '48000'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    name: '"Audio"'
    nconnections: '2'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RF Input"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: fm_baseband
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: 38kHz_carrier
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: r_minus_l
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: r_plus_l
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: fm_baseband
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: fm_baseband
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: 38kHz_carrier
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: r_plus_l
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: r_minus_l
  states: {}

connections:
- [analog_fm_deemph_0, '0', virtual_sink_2_0, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_0, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_0, '1']
- [analog_pll_refout_cc_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [analog_wfm_rcv_0, '0', low_pass_filter_1, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_wfm_rcv_0, '0', virtual_sink_0, '0']
- [band_pass_filter_0, '0', analog_pll_refout_cc_0, '0']
- [band_pass_filter_0, '0', blocks_float_to_complex_0, '0']
- [band_pass_filter_0_0, '0', blocks_null_sink_0, '0']
- [band_pass_filter_0_0, '0', virtual_sink_1, '0']
- [band_pass_filter_0_1, '0', blocks_multiply_xx_0_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_real_0, '0', virtual_sink_2, '0']
- [blocks_float_to_complex_0, '0', analog_pll_refout_cc_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0_0_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_freq_sink_x_0_0_1, '1']
- [blocks_multiply_xx_0, '0', band_pass_filter_0_0, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0_0_0, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0_0_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0_0_0, '0', blocks_complex_to_real_0, '0']
- [low_pass_filter_1, '0', analog_fm_deemph_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_1, '0']
- [virtual_source_0, '0', band_pass_filter_0, '0']
- [virtual_source_0, '0', band_pass_filter_0_1, '0']
- [virtual_source_0_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [virtual_source_1, '0', blocks_multiply_xx_0_0, '1']
- [virtual_source_2, '0', blocks_add_xx_0, '0']
- [virtual_source_2, '0', blocks_sub_xx_0, '0']
- [virtual_source_3, '0', blocks_add_xx_0, '1']
- [virtual_source_3, '0', blocks_sub_xx_0, '1']

metadata:
  file_format: 1
